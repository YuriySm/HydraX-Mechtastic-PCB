# Repository YuriySm/HydraX-Mechtastic-PCB

File README.md:

Українська версія 🇺🇦 README доступна в [README_UK-UA.md](README_UK-UA.md).

HydraX is a fork of the [Project Hydra (Meshtastic PCB)](https://github.com/Hydra-Designs/project-hydra-meshtastic-pcb).  It is built on Project Hydra’s foundation with new features and modifications.

# HydraX Meshtastic PCB

## Why?

Because I thought I could. I don’t think the efforts were worth it. :) [Original Project Hydra v2.1](https://github.com/Hydra-Designs/project-hydra-meshtastic-pcb) is already a great solution.

But I had a lot of fun with KiCad, and assembling, as well as debugging my mistakes (see [Warnings](#Warnings) section below.).

## Features
- Supports up to 30dbm (1 watt) transmit power *(Please check local ISM band regulations for power limitations)*
- OLED support via I2C
- GPS support via UART
- PSRAM support (Store & Forward Server mode)
- User button via pin header
- Switchable power rail (GPS power saving)
- ADC input for battery voltage sensing
- Single 5V input (no reverse polarity and overvoltage protection!)
- 3.3V output (or input if onboard buck converter is not assembled)
- Programmable via USB-Serial adapter (RTS/DTR are required for the on-board auto reset!)
- Buzzer for audio notifications
- 7-38V to 5V linear regulator (optional)

## Changes from original Project Hydra

- ESP32-WROOM-32U changed to ESP32-WROOM-32**D** with built-in antenna.
- 5V linear regulator added (optional, 7-35V input) with 5.1mm power jack.
- Buzzer connection with transistor driver added.
- PCB size increased a bit to accommodate new components an ESP antenna (40x52 mm).
- Wider PCB mounting holes, plate's corners rounded.
- Some small trace and footprint changes to comply DRC rules.

## Flaws

- Mounting hole H1 is too close to LoRa module, it does not overlap the hole, but it is very close.
- Mounting hole H1 is in non-standard position, not in the corner, and a bit smaller then others.
- USB to UART converter is not included, you need to use an external one.

## What was tested and works

I ordered bare PCB and assembled one myself.

- ESP32-WROOM-32D works, tested with Meshtastic firmware v. 2.7.7.
- Meshtastic works with eByte E22-400M30S (1W) LoRa module.
- 5V linear regulator works, tested with 12V input.
- Buzzer works.
- GPS power control works.

## What was not tested, does not work

- Auto reset options have worked never for me (put to the bootloader manually with no issues though).
- Haven't tested GPS module.
- Haven't tested OLED display.
- JLCPCB assembly service was not used, did not check the LCSC parts numbers.

## Schematics

Clickable:

Project was created in [KiCad](https://www.kicad.org/) 9.0.4.

## Assembly

### Warnings

Use either **R10** *or* **R11** resistor, not both.  R10 is for a 3.3V power output for GPS or other peripherals, R11 is for a 5V.

*Do not* solder **R16** if board powers GPS.

Do not solder **U4**, **C7**, **J3** (the 5V regulator) if you are using an external 5V power source.

Auto reset option is not nessecary if you willing to manually reset the device when uploading new firmware via J1 pins 7 (EN) and 8 (GPIO0).  If you do want auto reset, solder Q1, Q2, R3, R4.

### Bill of Materials

Interactive [iBom](KiCad/HydraX-Meshtastic-PCB/bom/ibom.html) is available.

### Soldering

- If needed, solder the 5V linear regulator.
- Solder other SMD components (except ESP32 and LoRa module).
- Check 5V output (if used) and 3.3V power rail to make sure polarity is correct and you have proper 3.3V.
- Solder ESP32 module, you can see ESP Wi-Fi, or upload simple scetch to test it.
- Add LoRa module (always keep the antenna connected).

### Options

- Use 5V linear regulator (U4, C7) only if you need to power the device from 7-35V.
- 5v/3.3V power output is optional, you can to power external devices (i.e. GPS module). Select power by using either R10 or R11, not both.
- Buzzer parts (R18, R19, Q3) are also optional. Use GPIO26 in the Meshtatic setting to enable it.
- R15 is optional, do not use it if you control GPS power via software (5v/3.3V power output).
- You can omit auto reset parts (Q1, Q2, R3, R4) as you can set ESP32 boot mode by EN and GPIO0 pins of J1 connector.

## Ordering from JLCPCB

Use Gerber files provided on the release page. JLCPCB assembly service was not tested, so please check the LCSC part numbers if needed.

## Programming

### Meshtastic target

The PCB is compatible with Meshtastic DIY v1 target and Meshtastic Hydra. Please check [Meshtastic documentation](https://meshtastic.org/docs/) for details.

### LoRa power

For most LoRa regions, you can't set the power above 20dBm in the firmware, so 1W power is not usable. To use full power you need to modify the firmware and set LoRa power to 22dBm (eByte will set LoRa module to max module power automatically).

### Flashing

You need an external USB to UART converter. Use J1 pins 4 and 5 for RX and TX, pins 3 and 5 for 5V power and GND.

If you soldered auto reset parts, connect RTS and DTR signals of your USB to UART converter to J1 pins 1 and 2 respectively.

If auto reset option does not work, you can put ESP32 to bootloader mode manually by keeping the J1 pin 8 (GPIO0) on the GND and putting shortly pin 7 (EN) to GND.

## Contributing

Please contribute using [Github Flow](https://guides.github.com/introduction/flow/). Create a branch, add commits, and [open a pull request.

## Support

We discuss PCB only here, not Meshtastic itself. I can not guarantee any support, but I will try to help if I can.

Please open an issue for support/ideas.

## License
[GPL v3](https://choosealicense.com/licenses/gpl-3.0/)

[Meshtastic](https://meshtastic.org/)® is a registered trademark of Meshtastic LLC. Meshtastic software components are released under various licenses, see github for details. No warranty is provided - use at your own risk.

This HydraX PCB based on [Project Hydra (Meshtastic PCB)](https://github.com/Hydra-Designs/project-hydra-meshtastic-pcb).

## KiCad design KiCad/HydraX-Meshtastic-PCB/HydraX-Meshtastic-PCB.kicad_pcb

Parts:
BZ1: TMB12A05; MagneticBuzzer_Kingstate_KCG0601
C1, C2, C4, C5, C6: 100n; C_0603_1608Metric; LCSC# C519438
C3, C10, C11, C12, C13: 22uF; C_0603_1608Metric; LCSC# C86295
C7: C_Polarized_Small; CP_Elec_4x3
D1: LED; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC# C434421
H1: tooling_hole; MountingHole_2.7mm_M2.5_Pad_Via
H2: tooling_hole; MountingHole_2.2mm_M2_Pad_Via
H3, H4: MountingHole; MountingHole_2.7mm_M2.5_Pad_Via
J1: programming header; PinHeader_1x08_P2.54mm_Vertical
J2: oled/gps/external HW; PinHeader_1x11_P2.54mm_Vertical
J3: Barrel_Jack_Switch; BarrelJack_Horizontal
J4: ipex antenna; U.FL_Molex_MCRF_73412-0110_horizontal; LCSC# C411563
L2: 4.7uH; chilsin_BMRA00040412; LCSC# C136097
NT1: Net-Tie_2; NetTie-2_SMD_Pad0.5mm
Q1, Q2, Q3, Q4: BC848; SOT-23; LCSC# C8577
Q5: CJ2301; SOT-23; LCSC# C8547
R1, R8: 470; R_0603_1608Metric; LCSC# C23179
R2, R10, R11, R16: 0; R_0603_1608Metric; LCSC# C15402
R3, R4, R5, R6, R7, R9, R12, R15, R17: 10k; R_0603_1608Metric; LCSC# C98220
R13: 536k; R_0603_1608Metric; LCSC# C227955
R14: 118k; R_0603_1608Metric; LCSC# C137804
R18: 1k; R_0603_1608Metric
R19: 1k; R_0603_1608Metric; LCSC# C98220
SYM1: Meshtastic Logo; meshtastic_logo
TP1, TP2: TestPoint; TestPoint_Pad_D1.0mm
U1: ESP32-WROOM-32D
U2: ESP-PSRAM64; SOIC-8_3.9x4.9mm_P1.27mm; LCSC# C261881
U3: E22-900M30S; e22-900m30s-handsoldering; LCSC# C411294
U4: L7805; TO-252-2
U5: PAM2312; SOT-23-5; LCSC# C157537

Connections:
+5V: BZ1.1 (+), C5.1, C10.1, C13.1, J1.3, R11.2, R19.2, U3.9 (VCC), U3.10 (VCC), U4.3 (OUT), U5.1 (EN), U5.4 (VIN)
/5V_pwrctrl: J2.5, U1.10 (IO25)
/DTR: J1.1, Q1.2 (E), R4.1
/EN: C1.1, J1.7, Q2.3 (C), R7.2, U1.3 (EN)
/ESP32_RX: R1.1, U1.34 (RXD0/IO3)
/ESP32_TX: R2.1, U1.35 (TXD0/IO1)
/GPIO0: J1.8, Q1.3 (C), R5.1, U1.25 (IO0)
/GPIO2: D1.2 (A), U1.24 (IO2)
/GPIO16: R6.1, U1.27 (IO16), U2.1 (~CE)
/GPS_PWR_enable: R12.1, R16.2, R17.2, U1.26 (IO4)
/GPS_RX: J2.9, U1.14 (IO12)
/GPS_TX: J2.10, U1.23 (IO15)
/GPS_pwr: J2.8, Q5.3 (D), R16.1
/RTS: J1.2, Q2.2 (E), R3.1
/SDI_SD1: U1.22 (SDI/SD1), U2.5 (SI/SIO)
/SDO_SD0: U1.21 (SDO/SD0), U2.2 (SO/SIO)
/SHD_SD2: U1.17 (SHD/SD2), U2.7 (SIO3)
/SRAM_CLK: U1.28 (IO17), U2.6 (SCLK)
/SWP_SD3: U1.18 (SWP/SD3), U2.3 (SIO2)
/USR_BTN: J2.3, R9.1, U1.5 (SENSOR_VN)
/e22_BUSY: U1.8 (IO32), U3.14 (BUSY)
/e22_DIO1: U1.9 (IO33), U3.13 (DIO1)
/e22_MISO: U1.31 (IO19), U3.16 (MISO)
/e22_MOSI: U1.12 (IO27), U3.17 (MOSI)
/e22_NRST: U1.37 (IO23), U3.15 (NRST)
/e22_NSS: U1.30 (IO18), U3.19 (NSS)
/e22_RXEN: U1.13 (IO14), U3.6 (RXEN)
/e22_SCK: U1.29 (IO5), U3.18 (SCK)
/e22_TXEN: U1.16 (IO13), U3.7 (TXEN)
/gpio_26: J2.2, R18.1, U1.11 (IO26)
/vbat_mon: C6.1, J2.4, U1.7 (IO35)
GNDA: C10.2, C11.2, C12.2, NT1.1, R14.2, U5.2 (GND)
unnamed: BZ1.2 (-), Q3.3 (C), R19.1
unnamed: D1.1 (K), R8.1
unnamed: J1.4, R1.2
unnamed: J1.5, R2.2
unnamed: J4.1 (In), U3.21 (ANT)
unnamed: Q1.1 (B), R3.2
unnamed: Q2.1 (B), R4.2
unnamed: Q3.1 (B), R18.2
unnamed: Q4.1 (B), R12.2
unnamed: Q4.3 (C), Q5.1 (G), R15.1
unnamed: Q5.2 (S), R10.1, R11.1, R15.2
unnamed: TP2.1, U1.6 (IO34)
unnamed: TP1.1, U1.4 (SENSOR_VP)
unnamed: C7.1, J3.1, U4.1 (IN)
unnamed: R13.2, R14.1, U5.5 (FB)
unnamed: L2.1, U5.3 (SW)

Notes on the sheet:
PSRAM option
GPIO option
5V/3.3V option
Auto reset option
status LED
Buzzer option

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
Board: 2 copper layers, 40.0 x 52.0 mm, 55 parts (3 on the bottom side), 52 nets.

## Commit log

2025-09-21 release/v2.2: modifiing fork of Hydra Project
2025-09-21 release/v2.2: KiCad dir moved from submodule to main repo
2025-09-21 release/v2.2: Readme edited
2025-09-21 Readme edited
2025-10-18 R15 corrected to R16 in the Readme
